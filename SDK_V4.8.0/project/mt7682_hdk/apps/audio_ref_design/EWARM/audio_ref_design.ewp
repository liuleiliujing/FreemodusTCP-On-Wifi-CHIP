# IAR project audio_ref_design.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: PCFG_OS=2; _REENT_SMALL; PRODUCT_VERSION=7682; MT5932_SINGLE_CONTEXT; MTK_ROM_VER=e2; MT7682_E2_ENABLE; E2_ROM_7682; MTK_CM4_WIFI_TASK_ENABLE; MTK_CM4_N9_SINGLE_IMG; MTK_HIF_HEADER_2DW; MTK_DEBUG_LEVEL_INFO; MTK_DEBUG_LEVEL_WARNING; MTK_DEBUG_LEVEL_ERROR; MTK_LWIP_ENABLE; MTK_MT7686_ENABLE; USE_HAL_DRIVER; MTK_WIFI_API_TEST_CLI_ENABLE; MTK_NVDM_ENABLE; FREERTOS_ENABLE; MTK_SMTCN_V5_ENABLE; MTK_WIFI_ROM_ENABLE; MTK_IPERF_ENABLE; MTK_PING_OUT_ENABLE; MTK_MINICLI_ENABLE; MTK_CLI_TEST_MODE_ENABLE; MTK_HAL_LOWPOWER_ENABLE; MTK_WIFI_PROFILE_ENABLE; DATA_PATH_87; MTK_WIFI_REPEATER_ENABLE; MTK_WIFI_WPS_ENABLE; MTK_AUDIO_MP3_ENABLED; MTK_I2S_ENABLED; MTK_TEMP_REMOVE
  ICCARM.CCDiagSuppress: Pa050,Ta022,Ta023
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\..\kernel\rtos\FreeRTOS; ..\..\..\..\..\kernel\rtos\FreeRTOS\Source\include; ..\..\..\..\..\driver\CMSIS\Device\MTK\mt7686\Include; ..\..\..\..\..\driver\CMSIS\Include; ..\..\..\..\..\driver\chip\mt7686\inc; ..\..\..\..\..\middleware\MTK\connsys\inc; ..\..\..\..\..\driver\chip\inc; ..\..\..\..\..\driver\chip\mt7686\src\common\include; ..\..\..\..\..\middleware\MTK\tftp\inc; ..\..\..\..\..\middleware\third_party\cjson\inc; ..\..\..\..\..\middleware\third_party\lwip\ports\include; ..\..\..\..\..\middleware\third_party\lwip\src\include; ..\..\..\..\..\middleware\third_party\lwip\src\include\lwip; ..\..\..\..\..\middleware\MTK\dhcpd\inc; ..\..\..\..\..\middleware\third_party\mbedtls\include; ..\..\..\..\..\middleware\third_party\mbedtls\configs; ..\..\..\..\..\middleware\MTK\minicli\inc; ..\..\..\..\..\middleware\third_party\mqtt\MQTTClient-C\src\mediatek; ..\..\..\..\..\middleware\third_party\mqtt\MQTTClient-C\src; ..\..\..\..\..\middleware\third_party\mqtt\MQTTPacket\src; ..\..\..\..\..\middleware\third_party\nghttp2\lib\includes; ..\..\..\..\..\middleware\third_party\nghttp2\lib\includes\nghttp2; ..\..\..\..\..\middleware\MTK\smtcn\inc; ..\..\..\..\..\middleware\third_party\sntp\inc; ..\..\..\..\..\middleware\third_party\xml\inc; ..\..\..\..\..\middleware\MTK\iperf\inc; ..\..\..\..\..\middleware\third_party\ping\inc; ..\..\..\..\..\project\common\bsp_ex\inc; ..\..\..\..\..\kernel\rtos\FreeRTOS\Source\portable\IAR\ARM_CM4F; ..\..\..\..\..\kernel\service\inc; ..\..\..\..\..\kernel\service\syslog\inc; ..\..\..\..\..\middleware\third_party\curve25519\inc; ..\..\..\..\..\middleware\third_party\ed25519\inc; ..\..\..\..\..\middleware\third_party\chacha20poly1305\inc; ..\..\..\..\..\middleware\third_party\srp\inc; ..\..\..\..\..\middleware\MTK\nvdm\inc; ..\..\..\..\..\middleware\MTK\nvdm_core\inc_core; ..\..\..\..\..\middleware\MTK\wifi_service\combo\inc; src\common\include; ..\..\..\..\..\kernel\service\inc; ..\..\..\..\..\driver\CMSIS\Device\MTK\mt7686\Include; ..\..\..\..\..\driver\CMSIS\Include; ..\..\inc; inc; ..\..\..\..\..\kernel\service\inc; ..\..\..\..\..\driver\CMSIS\Device\MTK\mt7686\Include; ..\..\..\..\..\driver\CMSIS\Include; ..\..\..\..\..\driver\chip\inc; ..\..\..\..\..\driver\board\mt7686_hdk\inc; ..\..\..\..\..\driver\chip\mt7686\src\common\include; ..\..\..\..\..\driver\chip\mt7686\inc; ..\..\..\..\..\kernel\service\inc; ..\..\..\..\..\driver\board\mt7686_hdk\ept\inc; ..\..\..\..\..\driver\CMSIS\Device\MTK\mt7686\Include; ..\..\..\..\..\kernel\rtos\FreeRTOS\Source\portable\IAR\mt7686; ..\..\..\..\..\kernel\rtos\FreeRTOS\Source\include; ..\..\..\..\..\kernel\rtos\FreeRTOS\Source\portable\IAR\ARM_CM4F; ..\..\..\..\..\kernel\service\inc; ..\..\..\..\..\kernel\service\inc; ..\..\..\..\..\kernel\rtos\FreeRTOS\Source\include; ..\..\..\..\..\middleware\MTK\minicli\inc; ..\..\..\..\..\project\mt7682_hdk\apps\audio_ref_design\inc; ..\..\..\..\..\driver\CMSIS\Include; ..\..\..\..\..\driver\CMSIS\Device\MTK\mt7686\Include; ..\..\..\..\..\driver\chip\mt7686\inc; ..\..\..\..\..\driver\chip\inc; ..\..\..\..\..\kernel\service\inc; ..\..\..\..\..\driver\board\mt7686_hdk\ept\inc; ..\..\..\..\..\middleware\MTK\verno\inc; ..\..\..\..\..\driver\board\mt7682_hdk\util; ..\..\..\..\..\middleware\MTK\wifi_stack\inc; ..\..\..\..\..\middleware\MTK\smtcn\inc; ..\..\..\..\..\middleware\MTK\verno\inc; ..\..\..\..\..\middleware\MTK\smtcn\inc\internal; ..\..\..\..\..\driver\board\mt7682_hdk\util\inc; ..\..\..\..\..\prebuilt\middleware\MTK\wifi_stack\inc; ..\..\..\..\..\middleware\third_party\fatfs\src; ..\..\..\..\..\middleware\MTK\audio\inc; ..\..\..\..\..\middleware\MTK\audio\mp3_codec\inc; ..\..\..\..\..\middleware\third_party\fatfs\src\portable\mt7682\inc
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\inc
  OBJCOPY.OOCOutputFile: audio_ref_design.bin
  ILINK.IlinkOutputFile: audio_ref_design.out
  ILINK.IlinkKeepSymbols: __bootloader
  ILINK.IlinkIcfFile: flash.icf
  ILINK.IlinkExtraOptions: --redirect malloc=pvPortMalloc; --redirect calloc=pvPortCalloc; --redirect realloc=pvPortRealloc; --redirect free=vPortFree; -f ..\..\..\..\..\prebuilt\middleware\MTK\wifi_stack\rom\e2\symboldef_link.h
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group audio
    ../../../../../prebuilt/middleware/MTK/audio/mp3_codec/lib/arm_cm4/: lib_mp3dec_CM4_IAR.a
    ../../../../../middleware/MTK/audio/mp3_codec/src/: mp3_codec_7682.c
  group bspex
    ../../../../common/bsp_ex/src/: lp_ex_sleep.c
  group connsys
    ../../../../../middleware/MTK/connsys/src/: connsys_bus.c connsys_driver.c connsys_util.c mt7686_ram_release_flash.c
  group dhcpd
    ../../../../../middleware/MTK/dhcpd/src/: dhcpd.c
  group driver/board
    ../../../../../driver/board/mt7682_hdk/util/src/: board_cli.c io_def.c sleep_manager_cli.c
    ../../../../../driver/board/mt7686_hdk/ept/src/: bsp_gpio_ept_config.c
    ../../../../../middleware/third_party/fatfs/src/portable/mt7682/src/: diskio.c diskio_sd.c
    ../../../../../middleware/third_party/fatfs/src/: ff.c
  group driver/chip
    ../../../../../driver/chip/mt7686/src/: hal_adc.c hal_aes.c hal_audio_internal_service.c hal_cache.c hal_cache_internal.c hal_clock.c hal_dcxo.c hal_des.c hal_dwt.c hal_eint.c hal_eint_internal.c hal_emi.c hal_flash_cfi.c hal_flash_combo_init.c hal_flash_combo_nor.c hal_flash_custom.c hal_flash_custom_sfi.c hal_flash_disk.c hal_flash_mtd.c hal_flash_mtd_common.c hal_flash_mtd_dal.c hal_gdma.c hal_gdma_internal.c hal_gpio.c hal_gpt.c hal_gpt_internal.c hal_i2c_master.c hal_i2c_master_internal.c hal_i2s.c hal_i2s_internal.c hal_log.c hal_md5.c hal_mpu.c hal_mpu_internal.c hal_msdc.c hal_nvic.c hal_nvic_internal.c hal_pdma_internal.c hal_pmu.c hal_pmu_wrap_interface.c hal_pwm.c hal_rtc.c hal_sd.c hal_sd_internal.c hal_sdio.c hal_sdio_internal.c hal_sdio_slave.c hal_sdio_slave_internal.c hal_sha.c hal_spi_master.c hal_spi_master_internal.c hal_spi_slave.c hal_spi_slave_internal.c hal_sys.c hal_trng.c hal_trng_internal.c hal_uart.c hal_uart_internal.c hal_wdt.c hal_wdt_internal.c
    ../../../../../prebuilt/driver/chip/mt7686/lib/: libhal_core_CM4_IAR.a libhal_protected_CM4_IAR.a
  group iperf
    ../../../../../middleware/MTK/iperf/src/: iperf_cli.c iperf_task.c
  group kernel
    ../../../../../kernel/service/src/: context_info_save.c exception_handler.c mtk_HeapSizeGuard.c os_cli.c os_port_callback.c os_trace_callback.c toi.c
    ../../../../../kernel/rtos/FreeRTOS/Source/: event_groups.c list.c queue.c tasks.c timers.c
    ../../../../../kernel/rtos/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../kernel/rtos/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
    ../../../../../kernel/rtos/FreeRTOS/Source/portable/IAR/mt7686/: port_tick.c
    ../../../../../kernel/service/syslog/src/: syslog.c syslog_cli.c
  group lwip
    ../../../../../middleware/third_party/lwip/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../../../../middleware/third_party/lwip/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../../../middleware/third_party/lwip/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../../../../middleware/third_party/lwip/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
    ../../../../../middleware/third_party/lwip/src/netif/: ethernet.c
    ../../../../../middleware/third_party/lwip/ports/: ethernetif.c lwip_cli.c lwip_log.c sys_arch.c
  group minicli
    ../../../../../prebuilt/middleware/MTK/minicli/lib/: libminicli_CM4_IAR.a
    ../../../../../middleware/MTK/minicli/src/: minicli_api.c
  group nvdm
    ../../../../../prebuilt/middleware/MTK/nvdm/lib/: libnvdm_CM4_IAR.a
    ../../../../../middleware/MTK/nvdm/src/: nvdm_cli.c nvdm_port.c
  group ping
    ../../../../../middleware/third_party/ping/src/: ping.c ping_cli.c
  group project/mt7682_hdk/apps/audio_ref_design
    ../src/: cli_cmds.c cli_def.c ept_eint_var.c ept_gpio_var.c main.c mem_layout_info.c mp3_codec_demo.c mp3_codec_sqc.c nau8810.c network_default_config.c nvdm_config.c regions_init.c sys_init.c system_mt7682.c wifi_lwip_helper.c wifi_nvdm_config.c
    ./: startup_mt7682.s
  group smtcn
    ../../../../../middleware/MTK/smtcn/src/: bsmtcn_ops.c ops_config.c smt_api.c smt_conn.c
    ../../../../../prebuilt/middleware/MTK/smtcn/lib/: libbcsmtcn_CM4_IAR.a
  group wifi_driver
    ../../../../../middleware/MTK/wifi_service/combo/src/: get_profile_string.c inband_queue_option.c misc.c wifi_cli.c wifi_cm4_scan.c wifi_inband_cli.c wifi_os_api.c wifi_private_cli.c wifi_profile.c wifi_repeater.c wifi_wps.c
    ../../../../../prebuilt/middleware/MTK/wifi_service/combo/lib/wifi_inic/: libwifi_CM4_IAR.a
    ../../../../../middleware/MTK/wifi_service/combo/src/wifi_os_ext/: os_util.c os_utils.c
    ../../../../../middleware/MTK/wifi_service/combo/src/init/: wifi_default_config.c wifi_init.c
  group wifi_stack
    ../../../../../prebuilt/middleware/MTK/wifi_stack/lib/: libwifi_ram_CM4_repeater_wps_IAR.a
