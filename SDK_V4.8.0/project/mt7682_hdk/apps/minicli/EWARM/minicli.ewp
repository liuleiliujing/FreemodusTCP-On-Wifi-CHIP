# IAR project minicli.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: PCFG_OS=2; _REENT_SMALL; PRODUCT_VERSION=7682; MT5932_SINGLE_CONTEXT; MTK_ROM_VER=e2; MT7682_E2_ENABLE; E2_ROM_7682; MTK_CM4_WIFI_TASK_ENABLE; MTK_CM4_N9_SINGLE_IMG; MTK_HIF_HEADER_2DW; MTK_DEBUG_LEVEL_INFO; MTK_DEBUG_LEVEL_WARNING; MTK_DEBUG_LEVEL_ERROR; MTK_LWIP_ENABLE; MTK_MT7686_ENABLE; USE_HAL_DRIVER; MTK_WIFI_API_TEST_CLI_ENABLE; MTK_NVDM_ENABLE; FREERTOS_ENABLE; MTK_SMTCN_V5_ENABLE; MTK_WIFI_ROM_ENABLE; MTK_IPERF_ENABLE; MTK_PING_OUT_ENABLE; MTK_MINICLI_ENABLE; MTK_CLI_TEST_MODE_ENABLE; MTK_HAL_LOWPOWER_ENABLE; MTK_WIFI_PROFILE_ENABLE; DATA_PATH_87; MTK_WIFI_REPEATER_ENABLE; MTK_WIFI_WPS_ENABLE
  ICCARM.CCDiagSuppress: Pa050,Ta022,Ta023
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\..\kernel\rtos\FreeRTOS; ..\..\..\..\..\kernel\rtos\FreeRTOS\Source\include; ..\..\..\..\..\driver\CMSIS\Device\MTK\mt7686\Include; ..\..\..\..\..\driver\CMSIS\Include; ..\..\..\..\..\driver\chip\mt7686\inc; ..\..\..\..\..\middleware\MTK\connsys\inc; ..\..\..\..\..\driver\chip\inc; ..\..\..\..\..\driver\chip\mt7686\src\common\include; ..\..\..\..\..\middleware\MTK\tftp\inc; ..\..\..\..\..\middleware\third_party\cjson\inc; ..\..\..\..\..\middleware\third_party\lwip\ports\include; ..\..\..\..\..\middleware\third_party\lwip\src\include; ..\..\..\..\..\middleware\third_party\lwip\src\include\lwip; ..\..\..\..\..\middleware\MTK\dhcpd\inc; ..\..\..\..\..\middleware\third_party\mbedtls\include; ..\..\..\..\..\middleware\third_party\mbedtls\configs; ..\..\..\..\..\middleware\MTK\minicli\inc; ..\..\..\..\..\middleware\third_party\mqtt\MQTTClient-C\src\mediatek; ..\..\..\..\..\middleware\third_party\mqtt\MQTTClient-C\src; ..\..\..\..\..\middleware\third_party\mqtt\MQTTPacket\src; ..\..\..\..\..\middleware\third_party\nghttp2\lib\includes; ..\..\..\..\..\middleware\third_party\nghttp2\lib\includes\nghttp2; ..\..\..\..\..\middleware\MTK\smtcn\inc; ..\..\..\..\..\middleware\third_party\sntp\inc; ..\..\..\..\..\middleware\third_party\xml\inc; ..\..\..\..\..\middleware\MTK\iperf\inc; ..\..\..\..\..\middleware\third_party\ping\inc; ..\..\..\..\..\project\common\bsp_ex\inc; ..\..\..\..\..\kernel\rtos\FreeRTOS\Source\portable\IAR\ARM_CM4F; ..\..\..\..\..\kernel\service\inc; ..\..\..\..\..\kernel\service\syslog\inc; ..\..\..\..\..\middleware\third_party\curve25519\inc; ..\..\..\..\..\middleware\third_party\ed25519\inc; ..\..\..\..\..\middleware\third_party\chacha20poly1305\inc; ..\..\..\..\..\middleware\third_party\srp\inc; ..\..\..\..\..\middleware\MTK\nvdm\inc; ..\..\..\..\..\middleware\MTK\nvdm_core\inc_core; ..\..\..\..\..\middleware\MTK\wifi_service\combo\inc; src\common\include; ..\..\..\..\..\kernel\service\inc; ..\..\..\..\..\driver\CMSIS\Device\MTK\mt7686\Include; ..\..\..\..\..\driver\CMSIS\Include; ..\..\inc; inc; ..\..\..\..\..\kernel\service\inc; ..\..\..\..\..\driver\CMSIS\Device\MTK\mt7686\Include; ..\..\..\..\..\driver\CMSIS\Include; ..\..\..\..\..\driver\chip\inc; ..\..\..\..\..\driver\board\mt7686_hdk\inc; ..\..\..\..\..\driver\chip\mt7686\src\common\include; ..\..\..\..\..\driver\chip\mt7686\inc; ..\..\..\..\..\kernel\service\inc; ..\..\..\..\..\driver\board\mt7686_hdk\ept\inc; ..\..\..\..\..\driver\CMSIS\Device\MTK\mt7686\Include; ..\..\..\..\..\kernel\rtos\FreeRTOS\Source\portable\IAR\mt7686; ..\..\..\..\..\kernel\rtos\FreeRTOS\Source\include; ..\..\..\..\..\kernel\rtos\FreeRTOS\Source\portable\IAR\ARM_CM4F; ..\..\..\..\..\kernel\service\inc; ..\..\..\..\..\kernel\service\inc; ..\..\..\..\..\kernel\rtos\FreeRTOS\Source\include; ..\..\..\..\..\middleware\MTK\minicli\inc; ..\..\..\..\..\project\mt7682_hdk\apps\minicli\inc; ..\..\..\..\..\driver\CMSIS\Include; ..\..\..\..\..\driver\CMSIS\Device\MTK\mt7686\Include; ..\..\..\..\..\driver\chip\mt7686\inc; ..\..\..\..\..\driver\chip\inc; ..\..\..\..\..\kernel\service\inc; ..\..\..\..\..\driver\board\mt7686_hdk\ept\inc; ..\..\..\..\..\middleware\MTK\verno\inc; ..\..\..\..\..\driver\board\mt7682_hdk\util; ..\..\..\..\..\middleware\MTK\wifi_stack\inc; ..\..\..\..\..\middleware\MTK\smtcn\inc; ..\..\..\..\..\middleware\MTK\verno\inc; ..\..\..\..\..\middleware\MTK\smtcn\inc\internal; ..\..\..\..\..\driver\board\mt7682_hdk\util\inc; ..\..\..\..\..\prebuilt\middleware\MTK\wifi_stack\inc
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\inc
  OBJCOPY.OOCOutputFile: minicli.bin
  ILINK.IlinkOutputFile: minicli.out
  ILINK.IlinkKeepSymbols: __bootloader
  ILINK.IlinkIcfFile: flash.icf
  ILINK.IlinkExtraOptions: --redirect malloc=pvPortMalloc; --redirect calloc=pvPortCalloc; --redirect realloc=pvPortRealloc; --redirect free=vPortFree; -f ..\..\..\..\..\prebuilt\middleware\MTK\wifi_stack\rom\e2\symboldef_link.h
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group app
    ../src/: ept_eint_var.c ept_gpio_var.c main.c regions_init.c sys_init.c
  group board
    ../../../../../driver/board/mt7686_hdk/ept/src/: bsp_gpio_ept_config.c
    ../../../../../driver/board/mt7682_hdk/util/src/: io_def.c
    ../../../../../middleware/MTK/wifi_service/combo/src/wifi_os_ext/: os_util.c os_utils.c
  group cmsis
    ./: startup_mt7682.s
    ../src/: system_mt7682.c
  group driver
    ../../../../../driver/chip/mt7686/src/: hal_adc.c hal_aes.c hal_cache.c hal_cache_internal.c hal_clock.c hal_dcxo.c hal_des.c hal_dwt.c hal_eint.c hal_eint_internal.c hal_emi.c hal_flash_cfi.c hal_flash_combo_init.c hal_flash_combo_nor.c hal_flash_custom.c hal_flash_custom_sfi.c hal_flash_disk.c hal_flash_mtd.c hal_flash_mtd_common.c hal_flash_mtd_dal.c hal_gdma.c hal_gdma_internal.c hal_gpio.c hal_gpt.c hal_gpt_internal.c hal_i2c_master.c hal_i2c_master_internal.c hal_i2s.c hal_i2s_internal.c hal_log.c hal_md5.c hal_mpu.c hal_mpu_internal.c hal_msdc.c hal_nvic.c hal_nvic_internal.c hal_pdma_internal.c hal_pmu.c hal_pmu_wrap_interface.c hal_pwm.c hal_rtc.c hal_sd.c hal_sd_internal.c hal_sdio.c hal_sdio_internal.c hal_sdio_slave.c hal_sdio_slave_internal.c hal_sha.c hal_spi_master.c hal_spi_master_internal.c hal_spi_slave.c hal_spi_slave_internal.c hal_sys.c hal_trng.c hal_trng_internal.c hal_uart.c hal_uart_internal.c hal_wdt.c hal_wdt_internal.c
  group kernel
    ../../../../../kernel/rtos/FreeRTOS/Source/: event_groups.c list.c queue.c tasks.c timers.c
    ../../../../../kernel/service/src/: exception_handler.c
    ../../../../../kernel/rtos/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../kernel/rtos/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
    ../../../../../kernel/rtos/FreeRTOS/Source/portable/IAR/mt7686/: port_tick.c
  group kservice
    ../../../../../kernel/service/src/: context_info_save.c os_port_callback.c toi.c
    ../../../../../kernel/service/syslog/src/: syslog.c
  group lib
    ../../../../../prebuilt/driver/chip/mt7686/lib/: libhal_core_CM4_IAR.a libhal_protected_CM4_IAR.a
    ../../../../../prebuilt/middleware/MTK/minicli/lib/: libminicli_CM4_IAR.a
  group minicli
    ../../../../../middleware/MTK/minicli/src/: minicli_api.c
